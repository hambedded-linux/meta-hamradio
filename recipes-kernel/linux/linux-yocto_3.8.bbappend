FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://hamradio.cfg \
            file://usb-serial.cfg \
            "
